v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 180 -1270 180 -1240 { lab=GND}
N 500 -1400 530 -1400 { lab=#net1}
N 180 -1680 180 -1660 { lab=VPWR}
N 180 -1380 380 -1380 { lab=start}
N 180 -1380 180 -1330 { lab=start}
N 340 -1420 380 -1420 { lab=outb}
N 340 -1530 340 -1420 { lab=outb}
N 340 -1530 2620 -1530 { lab=outb}
N 180 -1600 180 -1580 { lab=VGND}
N 180 -1460 180 -1440 { lab=GND}
N 180 -1540 180 -1520 { lab=VGND}
N 180 -1540 220 -1540 { lab=VGND}
N 220 -1540 220 -1520 { lab=VGND}
N 830 -1400 860 -1400 { lab=#net2}
N 1160 -1400 1190 -1400 { lab=#net3}
N 1490 -1400 1520 -1400 { lab=#net4}
N 1820 -1400 1850 -1400 { lab=#net5}
N 2150 -1400 2180 -1400 { lab=#net6}
N 2480 -1400 2510 -1400 { lab=#net7}
N 2810 -1400 2840 -1400 { lab=#net8}
N 830 -1000 860 -1000 { lab=#net9}
N 1160 -1000 1190 -1000 { lab=#net10}
N 1490 -1000 1520 -1000 { lab=#net11}
N 1820 -1000 1850 -1000 { lab=#net12}
N 2150 -1000 2180 -1000 { lab=#net13}
N 2480 -1000 2510 -1000 { lab=#net14}
N 2810 -1000 2840 -1000 { lab=#net15}
N 2620 -1530 3220 -1530 { lab=outb}
N 3220 -1530 3220 -1260 { lab=outb}
N 300 -1380 300 -1280 { lab=start}
N 500 -1000 530 -1000 { lab=#net16}
N 510 -1380 530 -1380 { lab=VPWR}
N 510 -1370 530 -1370 { lab=VPWR}
N 840 -1380 860 -1380 { lab=GND}
N 840 -1380 840 -1350 { lab=GND}
N 840 -1370 860 -1370 { lab=GND}
N 1170 -1380 1190 -1380 { lab=GND}
N 1170 -1380 1170 -1350 { lab=GND}
N 1170 -1370 1190 -1370 { lab=GND}
N 1500 -1380 1520 -1380 { lab=GND}
N 1500 -1380 1500 -1350 { lab=GND}
N 1500 -1370 1520 -1370 { lab=GND}
N 1830 -1380 1850 -1380 { lab=GND}
N 1830 -1380 1830 -1350 { lab=GND}
N 1830 -1370 1850 -1370 { lab=GND}
N 2160 -1380 2180 -1380 { lab=GND}
N 2160 -1380 2160 -1350 { lab=GND}
N 2160 -1370 2180 -1370 { lab=GND}
N 2490 -1380 2510 -1380 { lab=GND}
N 2490 -1380 2490 -1350 { lab=GND}
N 2490 -1370 2510 -1370 { lab=GND}
N 2820 -1380 2840 -1380 { lab=GND}
N 2820 -1380 2820 -1350 { lab=GND}
N 2820 -1370 2840 -1370 { lab=GND}
N 510 -980 530 -980 { lab=GND}
N 510 -980 510 -950 { lab=GND}
N 510 -970 530 -970 { lab=GND}
N 840 -980 860 -980 { lab=GND}
N 840 -980 840 -950 { lab=GND}
N 840 -970 860 -970 { lab=GND}
N 1170 -980 1190 -980 { lab=GND}
N 1170 -980 1170 -950 { lab=GND}
N 1170 -970 1190 -970 { lab=GND}
N 1500 -980 1520 -980 { lab=GND}
N 1500 -980 1500 -950 { lab=GND}
N 1500 -970 1520 -970 { lab=GND}
N 1830 -980 1850 -980 { lab=GND}
N 1830 -980 1830 -950 { lab=GND}
N 1830 -970 1850 -970 { lab=GND}
N 2160 -980 2180 -980 { lab=GND}
N 2160 -980 2160 -950 { lab=GND}
N 2160 -970 2180 -970 { lab=GND}
N 2490 -980 2510 -980 { lab=GND}
N 2490 -980 2490 -950 { lab=GND}
N 2490 -970 2510 -970 { lab=GND}
N 2820 -980 2840 -980 { lab=GND}
N 2820 -980 2820 -950 { lab=GND}
N 2820 -970 2840 -970 { lab=GND}
N 480 -1330 480 -1320 { lab=VPWR}
N 480 -1320 510 -1320 { lab=VPWR}
N 510 -1370 510 -1320 { lab=VPWR}
N 510 -1380 510 -1370 { lab=VPWR}
N 830 -1220 860 -1220 { lab=#net17}
N 1160 -1220 1190 -1220 { lab=#net18}
N 1490 -1220 1520 -1220 { lab=#net19}
N 1820 -1220 1850 -1220 { lab=#net20}
N 2150 -1220 2180 -1220 { lab=#net21}
N 2480 -1220 2510 -1220 { lab=#net22}
N 2810 -1220 2840 -1220 { lab=#net23}
N 510 -1200 530 -1200 { lab=GND}
N 510 -1200 510 -1170 { lab=GND}
N 510 -1190 530 -1190 { lab=GND}
N 840 -1200 860 -1200 { lab=GND}
N 840 -1200 840 -1170 { lab=GND}
N 840 -1190 860 -1190 { lab=GND}
N 1170 -1200 1190 -1200 { lab=GND}
N 1170 -1200 1170 -1170 { lab=GND}
N 1170 -1190 1190 -1190 { lab=GND}
N 1500 -1200 1520 -1200 { lab=GND}
N 1500 -1200 1500 -1170 { lab=GND}
N 1500 -1190 1520 -1190 { lab=GND}
N 1830 -1200 1850 -1200 { lab=GND}
N 1830 -1200 1830 -1170 { lab=GND}
N 1830 -1190 1850 -1190 { lab=GND}
N 2160 -1200 2180 -1200 { lab=GND}
N 2160 -1200 2160 -1170 { lab=GND}
N 2160 -1190 2180 -1190 { lab=GND}
N 2490 -1200 2510 -1200 { lab=GND}
N 2490 -1200 2490 -1170 { lab=GND}
N 2490 -1190 2510 -1190 { lab=GND}
N 2820 -1200 2840 -1200 { lab=GND}
N 2820 -1200 2820 -1170 { lab=GND}
N 2820 -1190 2840 -1190 { lab=GND}
N 830 -830 860 -830 { lab=#net24}
N 1160 -830 1190 -830 { lab=#net25}
N 1490 -830 1520 -830 { lab=#net26}
N 1820 -830 1850 -830 { lab=#net27}
N 2150 -830 2180 -830 { lab=#net28}
N 2480 -830 2510 -830 { lab=#net29}
N 2810 -830 2840 -830 { lab=#net30}
N 500 -830 530 -830 { lab=#net31}
N 510 -810 530 -810 { lab=GND}
N 510 -810 510 -780 { lab=GND}
N 510 -800 530 -800 { lab=GND}
N 840 -810 860 -810 { lab=GND}
N 840 -810 840 -780 { lab=GND}
N 840 -800 860 -800 { lab=GND}
N 1170 -810 1190 -810 { lab=GND}
N 1170 -810 1170 -780 { lab=GND}
N 1170 -800 1190 -800 { lab=GND}
N 1500 -810 1520 -810 { lab=GND}
N 1500 -810 1500 -780 { lab=GND}
N 1500 -800 1520 -800 { lab=GND}
N 1830 -810 1850 -810 { lab=GND}
N 1830 -810 1830 -780 { lab=GND}
N 1830 -800 1850 -800 { lab=GND}
N 2160 -810 2180 -810 { lab=GND}
N 2160 -810 2160 -780 { lab=GND}
N 2160 -800 2180 -800 { lab=GND}
N 2490 -810 2510 -810 { lab=GND}
N 2490 -810 2490 -780 { lab=GND}
N 2490 -800 2510 -800 { lab=GND}
N 2820 -810 2840 -810 { lab=GND}
N 2820 -810 2820 -780 { lab=GND}
N 2820 -800 2840 -800 { lab=GND}
N 300 -1280 300 -1020 { lab=start}
N 300 -1020 380 -1020 { lab=start}
N 3160 -1400 3160 -1290 { lab=#net32}
N 3140 -1400 3160 -1400 { lab=#net32}
N 520 -1220 530 -1220 { lab=#net32}
N 500 -1290 3160 -1290 { lab=#net32}
N 500 -1290 500 -1220 { lab=#net32}
N 500 -1220 520 -1220 { lab=#net32}
N 500 -890 500 -830 { lab=#net31}
N 500 -900 500 -890 { lab=#net31}
N 500 -900 3160 -900 { lab=#net31}
N 3160 -1000 3160 -910 { lab=#net31}
N 3160 -910 3160 -900 { lab=#net31}
N 3140 -1000 3160 -1000 { lab=#net31}
N 3140 -830 3220 -830 { lab=outb}
N 3220 -1260 3220 -830 { lab=outb}
N 340 -980 380 -980 { lab=outa}
N 340 -980 340 -730 { lab=outa}
N 340 -730 3270 -730 { lab=outa}
N 3270 -1220 3270 -730 { lab=outa}
N 3140 -1220 3270 -1220 { lab=outa}
N 420 -560 450 -560 { lab=outa}
N 420 -730 420 -560 { lab=outa}
N 630 -560 700 -560 { lab=div2}
N 420 -600 700 -600 { lab=outa}
N 680 -520 680 -500 { lab=GND}
N 680 -520 700 -520 { lab=GND}
N 420 -510 650 -510 { lab=#net33}
N 420 -540 420 -510 { lab=#net33}
N 420 -540 450 -540 { lab=#net33}
N 630 -540 650 -540 { lab=#net33}
N 650 -540 650 -510 { lab=#net33}
N 780 -580 880 -580 { lab=clkmux}
N 960 -580 1010 -580 { lab=cntclk}
C {devices/vsource.sym} 180 -1300 0 0 {name=V1 value="PULSE(0 1.8 100ns 1ns 1ns 9000ns 9000ns)"}
C {devices/gnd.sym} 180 -1240 0 0 {name=l2 lab=GND}
C {sky130_stdcells/nand2_4.sym} 440 -1400 0 0 {name=x21 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/code_shown.sym} 120 -360 0 0 {name=SPICE only_toplevel=false value="
.lib /home/harrison/workspace/sky130/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.include /home/harrison/workspace/sky130/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice

.control
save all
tran 0.1n 10u
set appendwrite
write unstablering2.out
.endc
"
}
C {devices/vdd.sym} 180 -1680 0 0 {name=l10 lab=VPWR}
C {devices/gnd.sym} 220 -1520 0 0 {name=l11 lab=VGND}
C {devices/vsource.sym} 180 -1630 0 0 {name=V2 value="PWL(0n 0.0 30n 1.8)"}
C {sky130_stdcells/nand2_4.sym} 440 -1000 0 0 {name=x47 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/vsource.sym} 180 -1490 0 0 {name=V3 value=0}
C {devices/gnd.sym} 180 -1440 0 0 {name=l21 lab=GND}
C {devices/gnd.sym} 180 -1580 0 0 {name=l20 lab=VGND}
C {devices/lab_wire.sym} 300 -1380 0 0 {name=l3 sig_type=std_logic lab=start}
C {devices/gnd.sym} 840 -1350 0 0 {name=l5 lab=GND}
C {devices/gnd.sym} 1170 -1350 0 0 {name=l6 lab=GND}
C {devices/gnd.sym} 1500 -1350 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 1830 -1350 0 0 {name=l8 lab=GND}
C {devices/gnd.sym} 2160 -1350 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} 2490 -1350 0 0 {name=l13 lab=GND}
C {devices/gnd.sym} 2820 -1350 0 0 {name=l14 lab=GND}
C {devices/gnd.sym} 510 -950 0 0 {name=l15 lab=GND}
C {devices/gnd.sym} 840 -950 0 0 {name=l16 lab=GND}
C {devices/gnd.sym} 1170 -950 0 0 {name=l17 lab=GND}
C {devices/gnd.sym} 1500 -950 0 0 {name=l19 lab=GND}
C {devices/gnd.sym} 1830 -950 0 0 {name=l22 lab=GND}
C {devices/gnd.sym} 2160 -950 0 0 {name=l23 lab=GND}
C {devices/gnd.sym} 2490 -950 0 0 {name=l24 lab=GND}
C {devices/gnd.sym} 2820 -950 0 0 {name=l25 lab=GND}
C {devices/title-2.sym} 0 -40 0 0 {name=l26 author="Harrison Pham" rev=1.0}
C {devices/vdd.sym} 480 -1330 0 0 {name=l1 lab=VPWR}
C {devices/gnd.sym} 510 -1170 0 0 {name=l4 lab=GND}
C {devices/gnd.sym} 840 -1170 0 0 {name=l27 lab=GND}
C {devices/gnd.sym} 1170 -1170 0 0 {name=l28 lab=GND}
C {devices/gnd.sym} 1500 -1170 0 0 {name=l29 lab=GND}
C {devices/gnd.sym} 1830 -1170 0 0 {name=l30 lab=GND}
C {devices/gnd.sym} 2160 -1170 0 0 {name=l31 lab=GND}
C {devices/gnd.sym} 2490 -1170 0 0 {name=l32 lab=GND}
C {devices/gnd.sym} 2820 -1170 0 0 {name=l33 lab=GND}
C {devices/gnd.sym} 510 -780 0 0 {name=l34 lab=GND}
C {devices/gnd.sym} 840 -780 0 0 {name=l35 lab=GND}
C {devices/gnd.sym} 1170 -780 0 0 {name=l36 lab=GND}
C {devices/gnd.sym} 1500 -780 0 0 {name=l37 lab=GND}
C {devices/gnd.sym} 1830 -780 0 0 {name=l38 lab=GND}
C {devices/gnd.sym} 2160 -780 0 0 {name=l39 lab=GND}
C {devices/gnd.sym} 2490 -780 0 0 {name=l40 lab=GND}
C {devices/gnd.sym} 2820 -780 0 0 {name=l41 lab=GND}
C {devices/lab_wire.sym} 3200 -830 0 0 {name=l18 sig_type=std_logic lab=outb}
C {devices/lab_wire.sym} 3200 -1220 0 0 {name=l9 sig_type=std_logic lab=outa}
C {sky130_stdcells/mux2_4.sym} 740 -580 0 0 {name=x34 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/gnd.sym} 680 -500 0 0 {name=l42 lab=GND}
C {sky130_stdcells/dfxbp_2.sym} 540 -550 0 0 {name=x36 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 850 -580 0 0 {name=l43 sig_type=std_logic lab=clkmux}
C {devices/lab_wire.sym} 680 -560 0 0 {name=l45 sig_type=std_logic lab=div2}
C {sky130_stdcells/clkbuf_4.sym} 920 -580 0 0 {name=x35 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/opin.sym} 1010 -580 0 0 {name=p1 lab=cntclk}
